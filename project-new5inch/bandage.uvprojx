# Keil uVision project bandage.uvprojx, settings and files
target hj20363 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103CB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bandage-rk3399 +hex
  BeforeMake: G:\desktop\HJ22388\danpianji_rk3399-7inch-lcd-221209\tools\before-build.bat
  AfterMake: G:\desktop\HJ22388\danpianji_rk3399-7inch-lcd-221209\tools\after-build.bat
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD
  c misc: --diag_suppress=177,550
  c include: ..\app;..\GD32F10x_standard_peripheral\Include;..\FreeRTOS\include;..\FreeRTOS\portable;..\microshell;..\CMSIS;..\CMSIS\GD\GD32F10x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../app/: app.c gd32f10x_it.c main.c cli_cmd.c serial_frame.c
  group Bsp
    ../app/: bsp.c bsp_debug_uart.c bsp_i2c_gpio.c bsp_pwm.c bsp_24cxx.c bsp_comm_uart-new5inch.c
  group CMSIS
    ../CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
    ../CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_md.s
  group Peripherals
    ../GD32F10x_standard_peripheral/Source/: gd32f10x_bkp.c gd32f10x_crc.c gd32f10x_dbg.c gd32f10x_exmc.c gd32f10x_fmc.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_rcu.c gd32f10x_timer.c gd32f10x_usart.c
  group FreeRTOS/SRC
    ../FreeRTOS/: list.c queue.c tasks.c
  group FreeRTOS/Port
    ../FreeRTOS/portable/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../app/: FreeRTOSConfig.h
  group MicroShell
    ../microshell/: ansi.c ansi_port.c nr_micro_shell.c
  group Libs
    ../app/: ringbuffer.c
